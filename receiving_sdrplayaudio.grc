<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>receiving_sdrplay</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>audio_gain</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label</key><value>Audio Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>100e-3</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>102.7e6</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>90e6</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>110e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>50</value></param>
<param><key>label</key><value>RF gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>70</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>audio_gain</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client_0</value></param>
<param><key>addr</key><value>192.168.1.2</value></param>
<param><key>callback</key><value>set_freq</value></param>
<param><key>port</key><value>30000</value></param>
<param><key>variable</key><value>freq</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client_1</value></param>
<param><key>addr</key><value>192.168.1.2</value></param>
<param><key>callback</key><value>set_rx_gain</value></param>
<param><key>port</key><value>30000</value></param>
<param><key>variable</key><value>20</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client_1_0</value></param>
<param><key>addr</key><value>192.168.1.2</value></param>
<param><key>callback</key><value>set_cutoff_freq</value></param>
<param><key>port</key><value>30000</value></param>
<param><key>variable</key><value>192e3</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client_1_0_0</value></param>
<param><key>addr</key><value>192.168.1.2</value></param>
<param><key>callback</key><value>set_trans_width</value></param>
<param><key>port</key><value>30000</value></param>
<param><key>variable</key><value>192e3</value></param>
</block>
<block>
<key>zeromq_pull_source</key>
<param><key>id</key><value>zeromq_pull_source_0</value></param>
<param><key>address</key><value>tcp://192.168.0.2:9997</value></param>
<param><key>type</key><value>float</value></param>
<param><key>timeout</key><value>0</value></param>
</block>
<block>
<key>zeromq_pull_source</key>
<param><key>id</key><value>zeromq_pull_source_1</value></param>
<param><key>address</key><value>tcp://192.168.0.2:9998</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>0</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_source_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
